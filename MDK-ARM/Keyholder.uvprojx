# Keil uVision project Keyholder.uvprojx, settings and files
target Keyholder (6190000::V6.19::ARMCLANG)
  device: STM32L151C8xxA STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.4.1
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: Keyholder +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 v6LangP=5 wLevel=1
  c define: USE_HAL_DRIVER,STM32L151xBA
  c include: ..\Includes;..\Source\ui;..\STM32Cube\Core\Inc;..\STM32Cube\Drivers\STM32L1xx_HAL_Driver\Inc;..\STM32Cube\Drivers\CMSIS\Include;..\STM32Cube\Middlewares\Third_Party\AL94_USB_Composite\COMPOSITE\Core\Inc;..\STM32Cube\Middlewares\Third_Party\AL94_USB_Composite\COMPOSITE\Class\CDC_ACM\Inc;..\STM32Cube\Middlewares\Third_Party\AL94_USB_Composite\COMPOSITE\Class\COMPOSITE\Inc;..\STM32Cube\Middlewares\Third_Party\AL94_USB_Composite\COMPOSITE\Class\HID_KEYBOARD\Inc;..\STM32Cube\Middlewares\Third_Party\AL94_USB_Composite\COMPOSITE\Target;..\STM32Cube\Composite;..\STM32Cube\Middlewares\Third_Party\AL94_USB_Composite\COMPOSITE\App;..\STM32Cube\Middlewares\ST\STM32_Cryptographic\include;..\STM32Cube\Drivers\STM32L1xx_HAL_Driver\Inc\Legacy;..\Libs\ugl\Include
  asm include: ..\Middlewares\ST\STM32_Cryptographic\include
  memory RVCT4: ROM 0x8000000 size 0xe000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ../Source/: buttons.c comd.c core.c crypto.c crypto_io.c flashd.c list.c ssd1306.c ssd1306_fonts.c ssd1306_tests.c system.c usbd.c utils.c
  group Source/ui
    ../Source/ui/: ui_core.c ui_menu_hotkey.c ui_menu_login.c ui_menu_logins.c ui_menu_main.c
  group CubeGenerated
    ../STM32Cube/Core/Src/: adc.c cmox_low_level.c dma.c gpio.c main.c rtc.c stm32l1xx_hal_msp.c stm32l1xx_it.c tim.c usb.c system_stm32l1xx.c usbd_cdc_acm_if.c
  group Application/MDK-ARM
    ./: startup_stm32l151xba.s
  group Drivers/STM32L1xx_HAL_Driver
    ../STM32Cube/Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal.c stm32l1xx_hal_adc.c stm32l1xx_hal_adc_ex.c stm32l1xx_hal_comp.c stm32l1xx_hal_cortex.c stm32l1xx_hal_crc.c stm32l1xx_hal_cryp.c stm32l1xx_hal_cryp_ex.c stm32l1xx_hal_dac.c stm32l1xx_hal_dac_ex.c stm32l1xx_hal_dma.c stm32l1xx_hal_exti.c stm32l1xx_hal_flash.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_gpio.c stm32l1xx_hal_i2c.c stm32l1xx_hal_i2s.c stm32l1xx_hal_irda.c stm32l1xx_hal_iwdg.c stm32l1xx_hal_lcd.c stm32l1xx_hal_nor.c stm32l1xx_hal_opamp.c stm32l1xx_hal_opamp_ex.c stm32l1xx_hal_pcd.c stm32l1xx_hal_pcd_ex.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_rtc.c stm32l1xx_hal_rtc_ex.c stm32l1xx_hal_sd.c stm32l1xx_hal_smartcard.c stm32l1xx_hal_smbus.c stm32l1xx_hal_spi.c stm32l1xx_hal_sram.c stm32l1xx_hal_tim.c stm32l1xx_hal_tim_ex.c stm32l1xx_hal_uart.c stm32l1xx_hal_usart.c stm32l1xx_hal_wwdg.c stm32l1xx_ll_adc.c stm32l1xx_ll_comp.c stm32l1xx_ll_crc.c stm32l1xx_ll_dac.c stm32l1xx_ll_dma.c stm32l1xx_ll_exti.c stm32l1xx_ll_fsmc.c stm32l1xx_ll_gpio.c stm32l1xx_ll_i2c.c stm32l1xx_ll_opamp.c stm32l1xx_ll_pwr.c stm32l1xx_ll_rcc.c stm32l1xx_ll_rtc.c stm32l1xx_ll_sdmmc.c stm32l1xx_ll_spi.c stm32l1xx_ll_tim.c stm32l1xx_ll_usart.c stm32l1xx_ll_usb.c stm32l1xx_ll_utils.c
  group Middlewares/Composite/USB/COMPOSITE/COMPOSITE
    ../STM32Cube/Middlewares/Third_Party/AL94_USB_Composite/COMPOSITE/Class/COMPOSITE/Src/: usbd_composite.c
  group Middlewares/Composite/USB/COMPOSITE/HID_KEYBOARD
    ../STM32Cube/Middlewares/Third_Party/AL94_USB_Composite/COMPOSITE/Class/HID_KEYBOARD/Src/: usbd_hid_keyboard.c
  group Middlewares/Composite/USB/COMPOSITE/Core
    ../STM32Cube/Middlewares/Third_Party/AL94_USB_Composite/COMPOSITE/Core/Src/: usbd_ioreq.c usbd_ctlreq.c usbd_core.c
    ../STM32Cube/Middlewares/Third_Party/AL94_USB_Composite/COMPOSITE/Target/: usbd_conf.c
    ../STM32Cube/Middlewares/Third_Party/AL94_USB_Composite/COMPOSITE/App/: usb_device.c usbd_desc.c
  group Middlewares/Composite/USB/COMPOSITE/CDC_ACM
    ../STM32Cube/Middlewares/Third_Party/AL94_USB_Composite/COMPOSITE/Class/CDC_ACM/Src/: usbd_cdc_acm.c
  group Libs/ugl/Source/legacy
    ../Libs/ugl/Source/legacy/: ugl_core.c ugl_item.c ugl_menu.c ugl_sprite.c ugl_text.c
software components: CMSIS:CORE 5.6.0
